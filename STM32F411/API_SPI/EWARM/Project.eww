<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Backup (1) of API.ewp</path>
    </project>
    <batchBuild />
</workspace>
